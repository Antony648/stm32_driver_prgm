# Keil uVision project gpio_proj.uvprojx, settings and files
target stm32f411 (6230000::V6.23::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio_proj
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group app
    ../antonygpio/: main.cpp
  group lib
    ../antonygpio/: stm32f4_cpp_gpio_lib.h stm32f4_gpio_lib.cpp stm32f4_gpio_lib.h my_strm32f4xx.h
  group drivers
    ../antonygpio/: stm32f4_gpio_driver.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.1.0
